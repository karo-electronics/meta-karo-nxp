CORE_IMAGE_BASE_INSTALL:append = " \
    glmark2 \
"

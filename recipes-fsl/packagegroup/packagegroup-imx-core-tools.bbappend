RDEPENDS:${PN}:remove = " \
    kernel-pcitest \
"

RDEPENDS:${PN}:remove = " \
    kernel-pcitest \
    can-utils \
"

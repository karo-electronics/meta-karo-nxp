SRC_URI:append = " \
    file://karo.bmp;subdir=git/tools/logos \
"

SRC_URI:append = " \
    file://dts/imx6qdl-tx6-emmc-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx6qdl-tx6-mb7-lcd-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx6qdl-tx6-mb7-rgb-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx6qdl-tx6-mb7.dtsi;subdir=git/arch/arm \
    file://dts/imx6qdl-tx6-nand-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx6qdl-tx6.dtsi;subdir=git/arch/arm \
    file://dts/imx6ul-txul-mb7-lcd-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx6ul-txul-mb7.dtsi;subdir=git/arch/arm \
    file://dts/imx6ul-txul-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx6ul-txul.dtsi;subdir=git/arch/arm \
    file://dts/imx8m-karo-pmic-bd71847.dtsi;subdir=git/arch/arm \
    file://dts/imx8m-karo-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx8m-karo.dtsi;subdir=git/arch/arm \
    file://dts/imx8m-qs8m-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx8m-qs8m.dtsi;subdir=git/arch/arm \
    file://dts/imx8mm-karo-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx8mm-karo.dtsi;subdir=git/arch/arm \
    file://dts/imx8mm-tx8m-16xx-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx8mm-tx8m-16xx.dtsi;subdir=git/arch/arm \
    file://dts/imx8mn-karo-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx8mn-karo.dtsi;subdir=git/arch/arm \
    file://dts/imx8mp-karo-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx8mp-karo.dtsi;subdir=git/arch/arm \
    file://dts/imx8mp-tx8p-lvds-mb.dtsi;subdir=git/arch/arm \
    file://dts/imx8mp-tx8p-ml81-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx8mp-tx8p-ml81.dts;subdir=git/arch/arm \
    file://dts/imx8mp-tx8p-ml81-lvds-mb-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx8mp-tx8p-ml81-lvds-mb.dts;subdir=git/arch/arm \
    file://dts/imx91-karo-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx91-karo.dtsi;subdir=git/arch/arm \
    file://dts/imx93-karo-u-boot.dtsi;subdir=git/arch/arm \
    file://dts/imx93-karo.dtsi;subdir=git/arch/arm \
"

COMPATIBLE_MACHINE = "(mx8-generic-bsp|mx9-nxp-bsp)"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-boards-add-support-for-qs95-5610-module.patch"

